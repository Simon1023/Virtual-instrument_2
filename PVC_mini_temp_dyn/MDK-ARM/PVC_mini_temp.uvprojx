# Keil uVision project PVC_mini_temp.uvprojx, settings and files
target PVC_mini_temp (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F767NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: PVC_mini_temp +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;..\lib_stm32f7_ov5653;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;..\Src\ImageProcess;..\Src\ImageProcess\Basic;..\Src\ImageProcess\Morphology
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0xc0000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: PVC_mini_temp\PVC_mini_temp.sct
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Application/User
    ../Src/: usbd_desc.c usbd_conf.c usb_device.c stm32f7xx_hal_msp.c main.c stm32f7xx_it.c usbd_cdc_if.c test.c is42s16160g-6bl.c usbd_storage_if.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_sdram.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_tim.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dsi.c stm32f7xx_ll_usb.c stm32f7xx_hal_cortex.c stm32f7xx_hal_eth.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2s.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_pcd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal.c
  group lib_stm32F4_ov5653
    ../lib_stm32f7_ov5653/: lib_stm32f7_ov5653.c lib_stm32f7_ov5653.h
  group ImageProcess/Basic
    ../Src/ImageProcess/Basic/Src/: binarization.c diagonal.c downsampling.c horizontalMirror.c verticalMirror.c projection.c
  group ImageProcess/EdgeDetect
    ../Src/ImageProcess/EdgeDetect/Src/: Canny.c cvMARR.c cvShen.c Differentiation.c Laplacian.c Prewitt.c Roberts.c Sobel.c
  group ImageProcess/Filter
    ../Src/ImageProcess/Filter/Src/: FreiChennFilter.c GaussianFilter.c KirschFilter.c LoGFilter.c MaxFilter.c MedianFilter.c MinFilter.c PrewiitFilter.c RobinsonFilter.c SharrFilter.c SobelFilter.c WeightedMedianFilter.c ZeroCrossFilter.c
  group ImageProcess/GLevelMorphology
    ../Src/ImageProcess/GLevelMorphology/Src/: grayClosing.c grayDilation.c grayErosion.c grayGradient.c grayLaplacian.c grayOpenning.c graySmoothing.c morphologicalContrastEnhance.c morphologicalThresholding.c
  group ImageProcess/Histogram Equalization
    ../Src/ImageProcess/Histogram Equalization/Src/: AHE.c HE.c LocalHE.c
  group ImageProcess/Smoothing
    ../Src/ImageProcess/Smoothing/Src/: convolution.c FltGaussian.c FltLocalAvg.c FltLowPass.c FltMedian.c
  group ImageProcess/Thinning
    ../Src/ImageProcess/Thinning/Src/: ArcelliBaja.c cvThinBest.c cvThinSTENT.c cvThinSTPP.c cvThinZ.c cvThinZH.c Thinning.c
  group ImageProcess/Threshold
    ../Src/ImageProcess/Threshold/Src/: cvThreITS.c cvThreJOH.c cvThreKAPUR.c cvThreLAP.c cvThreME.c cvThreMEAN.c cvThrePCT.c cvThrePEA.c cvThrePUN.c cvThreRDD.c cvThresRelax.c IterativeOtsu.c Optimal.c Otsu.c threBGcorrected.c threClustering.c threEntropy.c threFast.c threInterVariance.c threMetric.c threMoments.c threNiblack.c threshold.c
  group ImageProcess/Morphology
    ../Src/ImageProcess/Morphology/Src/: binaryClosing.c binaryDilation.c binaryErosion.c binaryOpenning.c EdgeDetection.c Residual.c
  group ImageProcess
    ../Src/: array_1d.c array_2d.c
software components: CMSIS:CORE 4.1.0
